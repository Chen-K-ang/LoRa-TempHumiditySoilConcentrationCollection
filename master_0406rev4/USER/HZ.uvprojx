# Keil uVision project HZ.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: HZ +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\HARDWARE\LED;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\STM32F10x_FWLib\inc;..\CORE;..\HARDWARE\KEY;..\MALLOC;..\HARDWARE\FLASH;..\FATFS\src;..\FATFS\exfuns;..\HARDWARE\Soil_Sensor;..\NET\onenet\inc;..\NET\NB-IOT;..\NET\device\inc;..\HARDWARE\HWTIMER;..\mcu_fun\inc;..\HARDWARE\BEEP;..\HARDWARE\IIC;..\HARDWARE\UART4;..\LORA;..\HARDWARE\TIMER;..\HARDWARE\W25QXX;..\HARDWARE\24CXX;..\HARDWARE\LCD;..\TEXT;..\USMART;..\HARDWARE\SD;..\HARDWARE\SPI
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/KEY/: key.c
    ../HARDWARE/FLASH/: flash.c
    ../HARDWARE/Soil_Sensor/: usart2.c soil.c
    ../HARDWARE/HWTIMER/: hwtimer.c
    ../HARDWARE/BEEP/: beep.c
    ../HARDWARE/IIC/: i2c_ee.c
    ../HARDWARE/UART4/: uart4.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/LCD/: lcd.c
    ../HARDWARE/SD/: MMC_SD.C
    ../HARDWARE/SPI/: spi.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_hd.s
  group FWLib
    ../STM32F10x_FWLib/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c misc.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_adc.c stm32f10x_exti.c stm32f10x_i2c.c stm32f10x_dma.c
  group MALLOC
    ../MALLOC/: malloc.c
  group USMART
    ../USMART/: usmart.c usmart_config.c usmart_str.c
  group README
    ../: README.TXT
  group Onenet
    ../NET/onenet/src/: dStream.c fault.c nb_callback.c onenet.c
  group net_device
    ../NET/device/src/: net_device.c net_io.c
  group NB-IOT
    ../NET/NB-IOT/: nb_cmd.c
  group mcu_fun
    ../mcu_fun/src/: mcu_adc.c mcu_dma.c mcu_exti.c mcu_gpio.c mcu_nvic.c mcu_rcc.c mcu_spi.c mcu_timer.c mcu_usart.c
  group LORA
    ../LORA/: lora_app_rev1.c lora_cfg.h lora_ui.c
  group TEXT
    ../TEXT/: fontupd.c text.c
  group FATFS
    ../FATFS/src/: diskio.c ff.c
    ../FATFS/exfuns/: exfuns.c mycc936.c fattester.c
